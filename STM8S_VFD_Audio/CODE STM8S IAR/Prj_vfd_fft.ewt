<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>FWLib</name>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_tim4.c</name>
    </file>
  </group>
  <group>
    <name>Main</name>
    <file>
      <name>$PROJ_DIR$\Main\main.c</name>
    </file>
  </group>
  <group>
    <name>Project</name>
    <file>
      <name>$PROJ_DIR$\ProjectLib\source\display.c</name>
    </file>
  </group>
  <group>
    <name>STM8S</name>
    <file>
      <name>$PROJ_DIR$\userSTM8\source\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\userSTM8\source\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\userSTM8\source\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\userSTM8\source\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\userSTM8\source\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\userSTM8\source\timer.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
  </group>
</project>


