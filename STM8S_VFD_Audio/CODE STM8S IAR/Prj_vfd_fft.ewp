# IAR project Prj_vfd_fft.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; FWlib\include; User\include; main; ProjectLib\include; UserSTM8\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: hex_vfd_fft.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    FWLib/source/: stm8s_adc1.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c
  group Main
    Main/: main.c
  group Project
    ProjectLib/source/: display.c
  group STM8S
    userSTM8/source/: adc.c clock.c delay.c gpio.c interrupt.c timer.c
